## cpu_tester_brpkg/Config.in
```kconfig
config BR2_PACKAGE_CPU_TESTER
	bool "cpu_tester"
	help
	  Simple monothread app to test cpu alive.

comment "Simple monothread app to test cpu alive"
```
